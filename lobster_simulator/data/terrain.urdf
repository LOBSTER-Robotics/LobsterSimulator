Commit message: Fixed terrain collisions

File: lobster_simulator/data/terrain.urdf (robot description, URDF)
Before this commit: robot terrain, 1 links, 0 joints
Links:
- link terrainLink: geometry collision mesh filename=terrain.obj scale=1 1 1; visual mesh filename=terrain.obj scale=1 1 1
